# Keil uVision project RemoteControl.uvprojx, settings and files
target RemoteControl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\USER;..\ALGORITHM\inc;..\CORE;..\FWLIB\inc;..\HARDWARE\inc;..\PERIPH\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ALGORITHM
    ../ALGORITHM/OLED_PERIPH/: oled_font.c oled_gui.c
    ../ALGORITHM/WAVE_FILTER/: wave_filter.c
    ../ALGORITHM/PACK_DEAL/: pack_deal.c
  group HARDWARE
    ../HARDWARE/GPIO/: drv_gpio.c
    ../HARDWARE/USART/: drv_usart.c
    ../HARDWARE/SYSTICK/: drv_systick.c
    ../HARDWARE/TIMER/: drv_timer.c
    ../HARDWARE/I2C/: drv_i2c.c
    ../HARDWARE/ADC/: drv_adc.c
    ../HARDWARE/SPI/: drv_spi.c
  group PERIPH
    ../PERIPH/OLED/: bsp_oled.c
    ../PERIPH/LED/: bsp_led.c
    ../PERIPH/KEY/: bsp_key.c
    ../PERIPH/RF24L01/: bsp_rf24l01.c
  group USER
    ./: main.c interrupt_task.c init.c system_stm32f4xx.c stm32f4xx_it.c
